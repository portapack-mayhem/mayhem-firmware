/*
 * Copyright (C) 2026 Ivan
 *
 * This file is part of PortaPack.
 *
 * This program is free software; you can redistribute it and/or modify
 * it under the terms of the GNU General Public License as published by
 * the Free Software Foundation; either version 2, or (at your option)
 * any later version.
 *
 * This program is distributed in the hope that it will be useful,
 * but WITHOUT ANY WARRANTY; without even the implied warranty of
 * MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
 * GNU General Public License for more details.
 *
 * You should have received a copy of the GNU General Public License
 * along with this program; see the file COPYING.  If not, write to
 * the Free Software Foundation, Inc., 51 Franklin Street,
 * Boston, MA 02110-1301, USA.
 */

/* NATIVE full-screen preview of the WSPR RX screen (UI v1.5 layout).
 *
 * This program drives the REAL StationListView (ui_station_list.hpp) through
 * the host shim (ui_shim/) with the REAL StationTable model and renders with
 * the REAL Mayhem fixed_8x16 glyph data (application/ui/ui_font_fixed_8x16.cpp
 * via the real Font::glyph and the ILI9341 bit order). Nothing is mocked
 * except the framework backend: model -> view -> painter is the device code
 * path.
 *
 * Frame: the COMPLETE 240x320 system frame, proving the real integration.
 *   physical y0..16   SystemView status strip (minimal "< WSPR RX" + clock
 *                     area), drawn at origin {0,0}
 *   physical y16..320 the application, drawn at its ACTUAL origin (the
 *                     painter is translated by +16), in app-local coordinates:
 *     local 0    radio row (dial, LNA/VGA)
 *     local 16   settings row (band, volume) - no MIN control any more
 *     local 32   RX RESTART / CLEAR LIST buttons
 *     local 56   STATUS line
 *     local 72   candidate panel line ("..." / "? CALL" / CALL)
 *     local 88   table header (CALL / N / GRID), generated by the list's own
 *                column constants
 *     local 104  4-row station list (row 0 selected + focused, inverted)
 *     local 256  visible-range summary ("1-4/12") BELOW the list
 *     local 272  LAST line, bottom at local 288 so it stays above the
 *                info-bar band; physical 288..304, fully visible
 *
 * The application viewport is 240x304, NOT the raw 240x320 screen: SystemView
 * reserves the top 16 px. The old preview painted an app at origin 0 and hid
 * the fact that LAST started at physical y320 (clipped); this renders the
 * system strip and offsets the app, so the geometry is verifiable on screen.
 *
 * Usage: wspr_station_list_preview <focused.ppm> [<blurred.ppm>]
 * Convert with ../ppm_to_png.py or sips.
 */

#include "ui_station_list.hpp"
#include "wspr_diag.hpp"

#include <cstdint>
#include <cstdio>
#include <cstring>

using namespace ui::external_app::wspr_rx;
using stations::StationTable;

namespace {

constexpr int SCREEN_W = wspr_layout::app_width;
constexpr int SCREEN_H = wspr_layout::physical_height;
constexpr int APP_TOP = wspr_layout::app_origin_y;
constexpr int LIST_Y = wspr_layout::list_y;
constexpr int LIST_H = wspr_layout::list_height(wspr_layout::app_viewport_height);
constexpr uint32_t BR_STEP = 352;

struct Screen {
    ui::HostFramebuffer fb;
    ui::Painter painter;
    StationTable table;
    StationListView list{{0, LIST_Y, SCREEN_W, LIST_H}};

    Screen() {
        fb.reset(SCREEN_W, SCREEN_H);
        painter.target(&fb);
        list.set_model(&table);
    }

    void text(int x, int y, const char* s, ui::Color fg) {
        painter.draw_string({(ui::Coord)x, (ui::Coord)y},
                            {ui::font::fixed_8x16, ui::Color::black(), fg}, s);
    }

    void button(int x, int y, int w, const char* label) {
        painter.fill_rectangle({(ui::Coord)x, (ui::Coord)y, (ui::Dim)w, 24},
                               ui::Color::darker_grey());
        const int len = (int)std::strlen(label);
        text(x + (w - len * 8) / 2, y + 4, label, ui::Color::light_grey());
    }

    /* Deterministic 12-station session. n_reports = number of unique
     * physical TX reports; n >= 2 repeats the same payload, which acquires
     * the session confirmation (which never expires afterwards). age_s is
     * the age of the LAST unique report relative to now. */
    void build(uint32_t now) {
        struct Row {
            const char* call;
            const char* grid;
            int8_t snr;
            int8_t dbm;
            uint8_t agreement;
            int16_t freq;
            uint16_t n;
            uint32_t age_s;
        };
        static const Row rows[12] = {
            {"R3DNC", "KO96", -5, 30, 100, 1493, 5, 30},
            {"VE2DPF", "FN48", -8, 27, 92, 1410, 2, 800},
            {"OH2XYZ", "KP20", 3, 37, 88, 1521, 1, 2000},
            {"K1ABC", "FN31", 12, 30, 100, 1445, 12, 4000},
            {"G4XYZ", "IO91", -1, 23, 75, 1480, 1, 90},
            {"VK6MOB", "OF78", 7, 33, 95, 1390, 3, 600},
            {"W2EEE", "FN20", -15, 20, 60, 1555, 1, 1500},
            {"JA1FF", "PM95", 2, 30, 90, 1462, 4, 240},
            {"DL8AA", "JO50", -6, 27, 84, 1425, 1, 300},
            {"I2BBB", "JN45", 9, 37, 100, 1580, 2, 1000},
            {"ON5CC", "JO21", 0, 30, 78, 1433, 1, 65},
            {"ZL3DD", "RE66", -3, 23, 70, 1595, 3, 900},
        };
        for (unsigned i = 0; i < 12; i++) {
            const Row& r = rows[i];
            /* All reports of one station carry the SAME payload, so the
             * second independent TX confirms. Reports are one slot apart. */
            const uint32_t first = now - r.age_s - (uint32_t)(r.n - 1) * 120;
            for (unsigned k = 0; k < r.n; k++) {
                table.report(r.call, r.grid, r.dbm, r.freq, r.snr,
                             r.agreement, first + k * 120,
                             900 + i * 8 * BR_STEP + k * BR_STEP, 40,
                             nullptr);
            }
        }
        table.visible_count();  // every accepted report is visible
    }
};

/* Renders the whole screen. focused selects the list focus state: with
 * focus the selected row is inverted (MenuView idiom), without it the row
 * keeps its colours on a darker background. */
void render(Screen& s, const bool list_focused, const uint32_t now) {
    s.build(now);
    s.list.set_now(now);
    s.list.notify_data_changed();
    s.list.on_encoder(0);  // select record 0
    if (list_focused)
        s.list.focus();

    /* ---- SystemView status strip: physical y0..16, origin {0,0} ----
     * Minimal but unmistakable: a separator line and a back/title area, so
     * the 16-px offset of the application below is visible in the image. */
    s.painter.set_origin({0, 0});
    s.painter.fill_rectangle({0, 0, SCREEN_W, APP_TOP},
                             ui::Color::darker_grey());
    s.painter.draw_string({2, 0},
                          {ui::font::fixed_8x16, ui::Color::darker_grey(),
                           ui::Color::light_grey()},
                          "< WSPR RX");
    s.painter.draw_string({SCREEN_W - 8 * 5, 0},
                          {ui::font::fixed_8x16, ui::Color::darker_grey(),
                           ui::Color::light_grey()},
                          "12:34");

    /* ---- Application: drawn at its ACTUAL origin, physical y+16 ---- */
    s.painter.set_origin({0, APP_TOP});
    s.painter.fill_rectangle({0, 0, SCREEN_W,
                              (ui::Dim)wspr_layout::app_viewport_height},
                             ui::Color::black());

    /* Radio row (approximate framework widgets; geometry matches the app). */
    s.text(0, 0, "28.124.600", ui::Color::light_grey());
    s.text(96, 0, "LNA 24", ui::Color::light_grey());
    s.text(160, 0, "VGA 30", ui::Color::light_grey());
    /* Settings row: band + volume; the MIN A% control is gone. */
    s.text(0, 16, "10m", ui::Color::light_grey());
    s.text(168, 16, "VOL 40", ui::Color::light_grey());

    /* Buttons. */
    s.button(4, 32, 14 * 8, "RX RESTART");
    s.button(15 * 8 + 8, 32, 14 * 8, "CLEAR LIST");

    /* STATUS line. */
    s.text(0, 56, "LOCKED  CAP 100%  FEC IDLE", ui::Color::green());

    /* Candidate panel : candidate states ONLY -
     * a pending candidate awaiting decode ("...", dark yellow) below the
     * STATUS line, above the header. Accepted reports render in the list. */
    {
        diag::CandidateState cand_state;
        cand_state.observe(1493, now - 12);
        char cand[diag::LINE_CHARS + 1];
        diag::format_candidate_panel(cand_state, now, cand);
        s.text(0, wspr_layout::cand_y, cand, ui::Color::dark_yellow());
    }

    /* Header row (v1.4 form): constant column labels at x0 and the
     * visible-range summary widget at x header_width, like the device. */
    {
        char header[24];
        StationListView::format_header_line(header);
        s.text(0, wspr_layout::header_y, header, ui::Color::light_grey());
        char summary[16];
        summary[0] = '\0';
        s.list.format_summary(summary);
        s.text(wspr_layout::summary_x, wspr_layout::header_y, summary,
               ui::Color::light_grey());
    }

    /* The list widget paints its own frame (rows + scrollbar). */
    s.list.paint(s.painter);

    /* LAST bottom-anchored inside the 304-px application viewport (physical
     * 288..304, above the info-bar band). The candidate panel already drew
     * the old summary band above it. */
    s.text(0, wspr_layout::last_y(wspr_layout::app_viewport_height),
           "LAST 12:34 STK 2048", ui::Color::dark_grey());
}

/* Write the framebuffer as a binary P6 PPM. */
bool write_ppm(const ui::HostFramebuffer& fb, const char* path) {
    FILE* f = std::fopen(path, "wb");
    if (!f)
        return false;
    std::fprintf(f, "P6\n%d %d\n255\n", SCREEN_W, SCREEN_H);
    for (int i = 0; i < SCREEN_W * SCREEN_H; i++) {
        const uint16_t v = fb.pixels[i];
        const uint8_t r5 = (v >> 11) & 0x1F;
        const uint8_t g6 = (v >> 5) & 0x3F;
        const uint8_t b5 = v & 0x1F;
        const uint8_t rgb[3] = {
            (uint8_t)((r5 * 255 + 15) / 31),
            (uint8_t)((g6 * 255 + 31) / 63),
            (uint8_t)((b5 * 255 + 15) / 31)};
        std::fwrite(rgb, 1, 3, f);
    }
    std::fclose(f);
    return true;
}

}  // namespace

int main(int argc, char** argv) {
    const char* out_path =
        (argc > 1) ? argv[1] : "ui_preview_fullscreen.ppm";
    const char* out_blur_path = (argc > 2) ? argv[2] : nullptr;

    /* A fixed clock so the age strings and their colours are deterministic:
     * the rows below are 30 s ... ~66 min old, showing fresh, dimming and
     * stale age colours while confirmed rows stay green. Large enough that
     * the first report of every row has a non-negative timestamp. */
    const uint32_t now = 20000;

    Screen focused_screen;
    render(focused_screen, true, now);
    if (!write_ppm(focused_screen.fb, out_path)) {
        std::fprintf(stderr, "error: cannot write %s\n", out_path);
        return 1;
    }

    if (out_blur_path) {
        Screen blurred_screen;
        render(blurred_screen, false, now);
        if (!write_ppm(blurred_screen.fb, out_blur_path)) {
            std::fprintf(stderr, "error: cannot write %s\n", out_blur_path);
            return 1;
        }
    }

    std::printf("wrote %s (%d stations, selection=%s, %s)\n", out_path,
                (int)focused_screen.table.count(),
                focused_screen.list.selected_callsign()
                    ? focused_screen.list.selected_callsign()
                    : "-",
                "focused");
    return 0;
}
