# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\..\..\os\kernel\include; ..\..\..\os\ports\common\ARMCMx; ..\..\..\os\ports\common\ARMCMx\CMSIS\include; ..\..\..\os\ports\IAR\ARMCMx; ..\..\..\os\ports\IAR\ARMCMx\LPC13xx; ..\..\..\os\hal\include; ..\..\..\os\hal\platforms\LPC13xx; ..\..\..\boards\EA_LPCXPRESSO_BB_1343; ..\..\..\test
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\; ..\..\..\os\ports\IAR\ARMCMx\LPC13xx; ..\..\..\boards\EA_LPCXPRESSO_BB_1343
  OBJCOPY.OOCOutputFile: ch.srec
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: ch.bin
  group (top)
    ../: chconf.h halconf.h main.c mcuconf.h
  group board
    ../../../boards/EA_LPCXPRESSO_BB_1343/: board.c board.h
  group os/hal/include
    ../../../os/hal/include/: adc.h can.h hal.h i2c.h mac.h mii.h mmc_spi.h pal.h pwm.h serial.h spi.h uart.h
  group os/hal/src
    ../../../os/hal/src/: adc.c can.c hal.c i2c.c mac.c mmc_spi.c pal.c pwm.c serial.c spi.c uart.c
  group os/kernel/include
    ../../../os/kernel/include/: ch.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chinline.h chioch.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group os/kernel/src
    ../../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group os/platform
    ../../../os/hal/platforms/LPC13xx/: core_cm3.h hal_lld.c hal_lld.h LPC13xx.h pal_lld.c pal_lld.h serial_lld.c serial_lld.h spi_lld.c spi_lld.h system_LPC13xx.h
  group os/port
    ../../../os/ports/IAR/ARMCMx/: chcore.c chcore.h chcore_v7m.c chcore_v7m.h chcoreasm_v7m.s chtypes.h cstartup.s
    ../../../os/ports/common/ARMCMx/: nvic.c nvic.h
  group os/port/LPC13xx
    ../../../os/ports/IAR/ARMCMx/LPC13xx/: cmparams.h vectors.s
  group test
    ../../../test/: test.c test.h testbmk.c testbmk.h testdyn.c testdyn.h testevt.c testevt.h testheap.c testheap.h testmbox.c testmbox.h testmsg.c testmsg.h testmtx.c testmtx.h testpools.c testpools.h testqueues.c testqueues.h testsem.c testsem.h testthd.c testthd.h
