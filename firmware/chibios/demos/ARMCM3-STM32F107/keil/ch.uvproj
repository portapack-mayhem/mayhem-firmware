# Keil uVision project ch.uvproj, settings and files
target Demo (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ch
  c flags: Optim=4 oTime=1
  c define: __heap_base__=Image$$RW_IRAM1$$ZI$$Limit __heap_end__=Image$$RW_IRAM2$$Base
  c include: ..\;..\..\..\os\kernel\include;..\..\..\os\ports\common\ARMCMx;..\..\..\os\ports\RVCT\ARMCMx;..\..\..\os\ports\RVCT\ARMCMx\STM32F1xx;..\..\..\os\hal\include;..\..\..\os\hal\platforms\STM32;..\..\..\os\hal\platforms\STM32F1xx;..\..\..\os\hal\platforms\STM32\GPIOv1;..\..\..\os\hal\platforms\STM32\DMAv1;..\..\..\os\hal\platforms\STM32\SPIv1;..\..\..\os\hal\platforms\STM32\USARTv1;..\..\..\os\various;..\..\..\boards\OLIMEX_STM32_P107;..\..\..\test
  asm misc: --cpreproc
  asm include: ..\;..\..\..\boards\OLIMEX_STM32_P107;..\..\..\os\ports\RVCT\ARMCMx\STM32F1xx
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x1
  group board
    ../../../boards/OLIMEX_STM32_P107/: board.c board.h
  group port
    ../../../os/ports/RVCT/ARMCMx/: cstartup.s chcoreasm_v7m.s chcore.c chcore_v7m.c chcore.h chcore_v7m.h chtypes.h
    ../../../os/ports/RVCT/ARMCMx/STM32F1xx/: vectors.s
    ../../../os/ports/common/ARMCMx/: nvic.c nvic.h
  group kernel
    ../../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
    ../../../os/kernel/include/: ch.h chbsem.h chcond.h chdebug.h chdynamic.h chevents.h chfiles.h chheap.h chinline.h chioch.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group hal
    ../../../os/hal/src/: adc.c can.c gpt.c hal.c i2c.c mac.c mmc_spi.c pal.c pwm.c serial.c serial_usb.c spi.c uart.c usb.c ext.c icu.c rtc.c sdc.c
    ../../../os/hal/include/: adc.h can.h gpt.h hal.h i2c.h mac.h mii.h mmc_spi.h pal.h pwm.h serial.h serial_usb.h spi.h uart.h usb.h ext.h icu.h rtc.h sdc.h usb_cdc.h
  group platform
    ../../../os/hal/platforms/STM32/: serial_lld.h
    ../../../os/hal/platforms/STM32/USARTv1/: serial_lld.c
    ../../../os/hal/platforms/STM32/GPIOv1/: pal_lld.h pal_lld.c
    ../../../os/hal/platforms/STM32F1xx/: stm32f10x.h hal_lld.c hal_lld.h hal_lld_f100.h hal_lld_f103.h hal_lld_f105_f107.h stm32_rcc.h stm32_dma.c stm32_dma.h
  group test
    ../../../test/: test.c testbmk.c testdyn.c testevt.c testheap.c testmbox.c testmsg.c testmtx.c testpools.c testqueues.c testsem.c testthd.c test.h testbmk.h testdyn.h testevt.h testheap.h testmbox.h testmsg.h testmtx.h testpools.h testqueues.h testsem.h testthd.h
  group demo
    ../: main.c chconf.h halconf.h mcuconf.h
