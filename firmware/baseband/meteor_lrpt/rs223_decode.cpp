/*
 * Copyright (C) 2026
 *
 * This file is part of PortaPack / Mayhem.
 *
 * Reed–Solomon decoder core is derived from Phil Karn's libfec `decode_rs.h`
 * (quiet/libfec), used under the GNU Lesser General Public License (LGPL).
 * GF tables match CCSDS (255,223): init_rs_char(8, 0x187, 112, 11, 32, 0).
 *
 * Depth-4 deinterleave layout matches SatDump Meteor LRPT usage (see `SATDUMP_VENDOR.md`).
 *
 * SPDX-License-Identifier: GPL-2.0-or-later
 */
#include "rs223_decode.hpp"

#include <algorithm>
#include <array>
#include <cstring>

namespace {
/* ---- GF(2^8) CCSDS (same as libfec gen_ccsds.c) ---- */
static const uint8_t kAlphaTo[] = {
    0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x87, 0x89, 0x95, 0xad, 0xdd, 0x3d, 0x7a, 0xf4,
    0x6f, 0xde, 0x3b, 0x76, 0xec, 0x5f, 0xbe, 0xfb, 0x71, 0xe2, 0x43, 0x86, 0x8b, 0x91, 0xa5, 0xcd,
    0x1d, 0x3a, 0x74, 0xe8, 0x57, 0xae, 0xdb, 0x31, 0x62, 0xc4, 0x0f, 0x1e, 0x3c, 0x78, 0xf0, 0x67,
    0xce, 0x1b, 0x36, 0x6c, 0xd8, 0x37, 0x6e, 0xdc, 0x3f, 0x7e, 0xfc, 0x7f, 0xfe, 0x7b, 0xf6, 0x6b,
    0xd6, 0x2b, 0x56, 0xac, 0xdf, 0x39, 0x72, 0xe4, 0x4f, 0x9e, 0xbb, 0xf1, 0x65, 0xca, 0x13, 0x26,
    0x4c, 0x98, 0xb7, 0xe9, 0x55, 0xaa, 0xd3, 0x21, 0x42, 0x84, 0x8f, 0x99, 0xb5, 0xed, 0x5d, 0xba,
    0xf3, 0x61, 0xc2, 0x03, 0x06, 0x0c, 0x18, 0x30, 0x60, 0xc0, 0x07, 0x0e, 0x1c, 0x38, 0x70, 0xe0,
    0x47, 0x8e, 0x9b, 0xb1, 0xe5, 0x4d, 0x9a, 0xb3, 0xe1, 0x45, 0x8a, 0x93, 0xa1, 0xc5, 0x0d, 0x1a,
    0x34, 0x68, 0xd0, 0x27, 0x4e, 0x9c, 0xbf, 0xf9, 0x75, 0xea, 0x53, 0xa6, 0xcb, 0x11, 0x22, 0x44,
    0x88, 0x97, 0xa9, 0xd5, 0x2d, 0x5a, 0xb4, 0xef, 0x59, 0xb2, 0xe3, 0x41, 0x82, 0x83, 0x81, 0x85,
    0x8d, 0x9d, 0xbd, 0xfd, 0x7d, 0xfa, 0x73, 0xe6, 0x4b, 0x96, 0xab, 0xd1, 0x25, 0x4a, 0x94, 0xaf,
    0xd9, 0x35, 0x6a, 0xd4, 0x2f, 0x5e, 0xbc, 0xff, 0x79, 0xf2, 0x63, 0xc6, 0x0b, 0x16, 0x2c, 0x58,
    0xb0, 0xe7, 0x49, 0x92, 0xa3, 0xc1, 0x05, 0x0a, 0x14, 0x28, 0x50, 0xa0, 0xc7, 0x09, 0x12, 0x24,
    0x48, 0x90, 0xa7, 0xc9, 0x15, 0x2a, 0x54, 0xa8, 0xd7, 0x29, 0x52, 0xa4, 0xcf, 0x19, 0x32, 0x64,
    0xc8, 0x17, 0x2e, 0x5c, 0xb8, 0xf7, 0x69, 0xd2, 0x23, 0x46, 0x8c, 0x9f, 0xb9, 0xf5, 0x6d, 0xda,
    0x33, 0x66, 0xcc, 0x1f, 0x3e, 0x7c, 0xf8, 0x77, 0xee, 0x5b, 0xb6, 0xeb, 0x51, 0xa2, 0xc3, 0x00,
};

static const uint8_t kIndexOf[] = {
    0xff, 0x00, 0x01, 0x63, 0x02, 0xc6, 0x64, 0x6a, 0x03, 0xcd, 0xc7, 0xbc, 0x65, 0x7e, 0x6b, 0x2a,
    0x04, 0x8d, 0xce, 0x4e, 0xc8, 0xd4, 0xbd, 0xe1, 0x66, 0xdd, 0x7f, 0x31, 0x6c, 0x20, 0x2b, 0xf3,
    0x05, 0x57, 0x8e, 0xe8, 0xcf, 0xac, 0x4f, 0x83, 0xc9, 0xd9, 0xd5, 0x41, 0xbe, 0x94, 0xe2, 0xb4,
    0x67, 0x27, 0xde, 0xf0, 0x80, 0xb1, 0x32, 0x35, 0x6d, 0x45, 0x21, 0x12, 0x2c, 0x0d, 0xf4, 0x38,
    0x06, 0x9b, 0x58, 0x1a, 0x8f, 0x79, 0xe9, 0x70, 0xd0, 0xc2, 0xad, 0xa8, 0x50, 0x75, 0x84, 0x48,
    0xca, 0xfc, 0xda, 0x8a, 0xd6, 0x54, 0x42, 0x24, 0xbf, 0x98, 0x95, 0xf9, 0xe3, 0x5e, 0xb5, 0x15,
    0x68, 0x61, 0x28, 0xba, 0xdf, 0x4c, 0xf1, 0x2f, 0x81, 0xe6, 0xb2, 0x3f, 0x33, 0xee, 0x36, 0x10,
    0x6e, 0x18, 0x46, 0xa6, 0x22, 0x88, 0x13, 0xf7, 0x2d, 0xb8, 0x0e, 0x3d, 0xf5, 0xa4, 0x39, 0x3b,
    0x07, 0x9e, 0x9c, 0x9d, 0x59, 0x9f, 0x1b, 0x08, 0x90, 0x09, 0x7a, 0x1c, 0xea, 0xa0, 0x71, 0x5a,
    0xd1, 0x1d, 0xc3, 0x7b, 0xae, 0x0a, 0xa9, 0x91, 0x51, 0x5b, 0x76, 0x72, 0x85, 0xa1, 0x49, 0xeb,
    0xcb, 0x7c, 0xfd, 0xc4, 0xdb, 0x1e, 0x8b, 0xd2, 0xd7, 0x92, 0x55, 0xaa, 0x43, 0x0b, 0x25, 0xaf,
    0xc0, 0x73, 0x99, 0x77, 0x96, 0x5c, 0xfa, 0x52, 0xe4, 0xec, 0x5f, 0x4a, 0xb6, 0xa2, 0x16, 0x86,
    0x69, 0xc5, 0x62, 0xfe, 0x29, 0x7d, 0xbb, 0xcc, 0xe0, 0xd3, 0x4d, 0x8c, 0xf2, 0x1f, 0x30, 0xdc,
    0x82, 0xab, 0xe7, 0x56, 0xb3, 0x93, 0x40, 0xd8, 0x34, 0xb0, 0xef, 0x26, 0x37, 0x0c, 0x11, 0x44,
    0x6f, 0x78, 0x19, 0x9a, 0x47, 0x74, 0xa7, 0xc1, 0x23, 0x53, 0x89, 0xfb, 0x14, 0x5d, 0xf8, 0x97,
    0x2e, 0x4b, 0xb9, 0x60, 0x0f, 0xed, 0x3e, 0xe5, 0xf6, 0x87, 0xa5, 0x17, 0x3a, 0xa3, 0x3c, 0xb7,
};

constexpr int kNn = 255;
constexpr int kNroots = 32;
constexpr int kPad = 0;
constexpr int kFcr = 112;
constexpr int kPrim = 11;
constexpr int kIprim = 116;
constexpr int kA0 = kNn;
constexpr int kNoEras = 0;

static inline int modnn255(int x) {
    while (x >= kNn) {
        x -= kNn;
        x = (x >> 8) + (x & 255);
    }
    return x;
}

/* Phil Karn DECODE_RS (decode_rs.h), pad=0, no erasures. Returns -1 if uncorrectable, else 0. */
static int decode_rs255_inplace(uint8_t* data) {
    int deg_lambda = 0, el = 0, deg_omega = 0;
    int i = 0, j = 0, r = 0, k = 0;
    uint8_t q = 0, tmp = 0, num1 = 0, num2 = 0, den = 0, discr_r = 0;
    std::array<uint8_t, kNroots + 1> lambda{};
    std::array<uint8_t, kNroots> s{};
    std::array<uint8_t, kNroots + 1> b{};
    std::array<uint8_t, kNroots + 1> t{};
    std::array<uint8_t, kNroots + 1> omega{};
    std::array<uint8_t, kNroots> root{};
    std::array<uint8_t, kNroots + 1> reg{};
    std::array<uint8_t, kNroots> loc{};
    int syn_error = 0;
    int count = 0;

    for (i = 0; i < kNroots; i++)
        s[(size_t)i] = data[0];

    for (j = 1; j < kNn - kPad; j++) {
        for (i = 0; i < kNroots; i++) {
            if (s[(size_t)i] == 0) {
                s[(size_t)i] = data[j];
            } else {
                s[(size_t)i] = data[j] ^ kAlphaTo[modnn255((int)kIndexOf[s[(size_t)i]] + (kFcr + i) * kPrim)];
            }
        }
    }

    syn_error = 0;
    for (i = 0; i < kNroots; i++) {
        syn_error |= s[(size_t)i];
        s[(size_t)i] = kIndexOf[s[(size_t)i]];
    }

    if (!syn_error)
        return 0;

    lambda.fill(0);
    lambda[0] = 1;

    for (i = 0; i < kNroots + 1; i++)
        b[(size_t)i] = kIndexOf[lambda[(size_t)i]];

    r = kNoEras;
    el = kNoEras;
    while (++r <= kNroots) {
        discr_r = 0;
        for (i = 0; i < r; i++) {
            if ((lambda[(size_t)i] != 0) && (s[(size_t)(r - i - 1)] != kA0)) {
                discr_r ^= kAlphaTo[modnn255((int)kIndexOf[lambda[(size_t)i]] + (int)s[(size_t)(r - i - 1)])];
            }
        }
        discr_r = kIndexOf[discr_r];
        if (discr_r == kA0) {
            std::memmove(&b[1], &b[0], kNroots * sizeof(b[0]));
            b[0] = (uint8_t)kA0;
        } else {
            t[0] = lambda[0];
            for (i = 0; i < kNroots; i++) {
                if (b[(size_t)i] != kA0)
                    t[(size_t)i + 1] = lambda[(size_t)i + 1] ^ kAlphaTo[modnn255((int)discr_r + (int)b[(size_t)i])];
                else
                    t[(size_t)i + 1] = lambda[(size_t)i + 1];
            }
            if (2 * el <= r + kNoEras - 1) {
                el = r + kNoEras - el;
                for (i = 0; i <= kNroots; i++)
                    b[(size_t)i] = (lambda[(size_t)i] == 0) ? (uint8_t)kA0 : (uint8_t)modnn255((int)kIndexOf[lambda[(size_t)i]] - (int)discr_r + kNn);
            } else {
                std::memmove(&b[1], &b[0], kNroots * sizeof(b[0]));
                b[0] = (uint8_t)kA0;
            }
            std::memcpy(lambda.data(), t.data(), (kNroots + 1) * sizeof(t[0]));
        }
    }

    deg_lambda = 0;
    for (i = 0; i < kNroots + 1; i++) {
        lambda[(size_t)i] = kIndexOf[lambda[(size_t)i]];
        if (lambda[(size_t)i] != kA0)
            deg_lambda = i;
    }

    std::memcpy(&reg[1], &lambda[1], kNroots * sizeof(reg[0]));
    count = 0;
    for (i = 1, k = kIprim - 1; i <= kNn; i++, k = modnn255(k + kIprim)) {
        q = 1;
        for (j = deg_lambda; j > 0; j--) {
            if (reg[(size_t)j] != kA0) {
                reg[(size_t)j] = (uint8_t)modnn255((int)reg[(size_t)j] + j);
                q ^= kAlphaTo[reg[(size_t)j]];
            }
        }
        if (q != 0)
            continue;
        root[(size_t)count] = (uint8_t)i;
        loc[(size_t)count] = (uint8_t)k;
        if (++count == deg_lambda)
            break;
    }
    if (deg_lambda != count)
        return -1;

    deg_omega = deg_lambda - 1;
    for (i = 0; i <= deg_omega; i++) {
        tmp = 0;
        for (j = i; j >= 0; j--) {
            if ((s[(size_t)(i - j)] != kA0) && (lambda[(size_t)j] != kA0))
                tmp ^= kAlphaTo[modnn255((int)s[(size_t)(i - j)] + (int)lambda[(size_t)j])];
        }
        omega[(size_t)i] = kIndexOf[tmp];
    }

    for (j = count - 1; j >= 0; j--) {
        num1 = 0;
        for (i = deg_omega; i >= 0; i--) {
            if (omega[(size_t)i] != kA0)
                num1 ^= kAlphaTo[modnn255((int)omega[(size_t)i] + i * (int)root[(size_t)j])];
        }
        num2 = kAlphaTo[modnn255((int)root[(size_t)j] * (kFcr - 1) + kNn)];
        den = 0;
        for (i = std::min(deg_lambda, kNroots - 1) & ~1; i >= 0; i -= 2) {
            if (lambda[(size_t)(i + 1)] != kA0)
                den ^= kAlphaTo[modnn255((int)lambda[(size_t)(i + 1)] + i * (int)root[(size_t)j])];
        }
        if (num1 != 0 && loc[(size_t)j] >= kPad) {
            data[loc[(size_t)j] - kPad] ^= kAlphaTo[modnn255((int)kIndexOf[num1] + (int)kIndexOf[num2] + kNn - (int)kIndexOf[den])];
        }
    }
    return count;
}

static void deinterleave4(const uint8_t* data, uint8_t* out, int pos) {
    for (int ii = 0; ii < 255; ii++)
        out[ii] = data[ii * 4 + pos];
}

static void interleave4(const uint8_t* in, uint8_t* data, int pos) {
    for (int ii = 0; ii < 255; ii++)
        data[ii * 4 + pos] = in[ii];
}

}  // namespace

bool meteor_lrpt_rs_decode_interleaved_depth4(uint8_t* body1020, int16_t* errors_out4) {
    std::array<uint8_t, 255> buff{};
    std::array<uint8_t, 255> saved{};
    bool all_ok = true;

    for (int b = 0; b < 4; b++) {
        deinterleave4(body1020, buff.data(), b);
        std::memcpy(saved.data(), buff.data(), 255);
        const int dec = decode_rs255_inplace(buff.data());
        if (dec < 0) {
            errors_out4[b] = -1;
            interleave4(saved.data(), body1020, b);
            all_ok = false;
        } else {
            int fixes = 0;
            for (int i = 0; i < 223; i++) {
                if (buff[(size_t)i] != saved[(size_t)i])
                    fixes++;
            }
            errors_out4[b] = (int16_t)fixes;
            interleave4(buff.data(), body1020, b);
        }
    }
    return all_ok;
}
